# IAR project ndas_ti_rtos.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: CC3200 TexasInstruments CC3200
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: ewarm; USE_FREERTOS; SL_PLATFORM_MULTI_THREADED; ENABLE_NEW_SIVY; TARGET_IS_CC3200; NDEBUG
  ICCARM.CCIncludePath2: ; ..\; ..\log; ..\gps; ..\sensor; ..\adc; ..\pwm; ..\sdcard; ..\utils; ..\periph; ..\proto; ..\sintab; ..\..\cc3200_libs\common; ..\..\cc3200_libs\inc\; ..\..\cc3200_libs\simplelink\; ..\..\cc3200_libs\simplelink\include\; ..\..\cc3200_libs\simplelink_extlib\provisioninglib\; ..\..\cc3200_libs\driverlib\; ..\..\cc3200_libs\fatfs\; ..\..\cc3200_libs\oslib; C:\Program Files\IAR Systems\Embedded Workbench 7.2\arm\CMSIS\Include
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 2
  OBJCOPY.OOCOutputFile: ndas.bin
  ILINK.IlinkOutputFile: ndas_ti_rtos.out
  ILINK.IlinkConfigDefines: TARGET_IS_CC3200=1
  ILINK.IlinkIcfFile: cc3200.icf
  ILINK.IlinkAdditionalLibs: ..\..\cc3200_libs\ewarm_libs\fatfs.a; ..\..\cc3200_libs\ewarm_libs\free_rtos.a; ..\..\cc3200_libs\ewarm_libs\simplelink.a; ..\..\cc3200_libs\ewarm_libs\driverlib.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ../: main.c
  group adc
    ../adc/: ads131.c
  group gps
    ../gps/: gps.c timtick.c
  group log
    ../log/: log.c minIni.c
  group periph
    ../periph/: board.c calib.c dma.c led.c myspi.c rtos_handlers.c twi.c xchg.c
    ../../cc3200_libs/common/: startup_ewarm.c
  group proto
    ../proto/: proto.c status.c
  group pwm
    ../pwm/: pwm.c
  group sdcard
    ../sdcard/: sdcard.c sdreader.c
  group sensor
    ../sensor/: sensor.c
  group sintab
    ../sintab/: sintab.c
  group utils
    ../utils/: circbuf.c compass.c userfunc.c
